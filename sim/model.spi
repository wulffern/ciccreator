*Top level TB

*----------------------------------------------------------------------------
* INCLUDES
*----------------------------------------------------------------------------
.include aimspice_model.spi
*.include ngspice_model.spi
*.include eldo_model.spi

.include ../lay/SAR_ESSCIRC16_28N.spice
